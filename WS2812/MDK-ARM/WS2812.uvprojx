# Keil uVision project WS2812.uvprojx, settings and files
target WS2812 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: WS2812 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\User\RTT;..\User\Application;..\User\Driver\MCU Driver;..\User\Driver\Peripheral Driver;..\User\FrameWork;..\User\Function
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/User
    ../Src/: main.c gpio.c dma.c spi.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group APP
    ../User/Application/: ApplicationMain.c ApplicationMain.h
  group MCUDriver
    ../User/Driver/MCU Driver/: SPI2.c SPI2.h LEDGPIO.c LEDGPIO.h KEYGPIO.c KEYGPIO.h
  group PeripheralDriver
    ../User/Driver/Peripheral Driver/: WS2812Config.c WS2812Config.h PeripheralMain.c PeripheralMain.h LEDConfig.c LEDConfig.h
  group FrameWork
    ../User/FrameWork/: WS2812.c WS2812.h LEDControl.c LEDControl.h KeyFrame.c KeyFrame.h
  group RTT
    ../User/RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
  group Function
    ../User/Function/: FunctionMain.c FunctionMain.h KeyFunc.c KeyFunc.h
software components: CMSIS:CORE 4.3.0
